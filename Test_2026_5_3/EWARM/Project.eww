<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Test_2026_5_3.ewp</path>
  </project>
  <batchBuild />
</workspace>
